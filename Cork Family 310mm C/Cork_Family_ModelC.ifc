Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-12-19T03:01:28
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Dec 19 03:01:28 2018 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{A3F8CB25-1D2E-4F47-B2D4-32C3705289EC}\ifc * Database version: 5507 * Database creation date: Wed Dec 19 03:01:27 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Dec 19 03:01:27 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Dec 19 03:01:27 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Cork - Model C, CONV_Vitra_DmstcChrs_CorkC:Cork - Model C:310544
In: Level 1
Material: Untreated cork
Pset_ManufacturerTypeInformation - ModelReference: 21002401; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.3007 m2; Volume: 0.031713 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_CorkC: Cork - Model C; Family and Type: CONV_Vitra_DmstcChrs_CorkC: Cork - Model C; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_CorkC: Cork - Model C; Type Id: CONV_Vitra_DmstcChrs_CorkC: Cork - Model C; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_CorkA; ConvergoRefNr: 0089-1812-0179-CH; ManufacturerName: Vitra; ManufacturerURL: www.vitra.com; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The three robust members of the Cork Family stand firmly, making them suited for use as side tables or stools. They benefit from the advantageous natural properties of cork: comparatively lightweight and extremely durable, they also have a velvety surface that is pleasant to touch.; Revision: n/a; Uniclass2: Pr_40_50_12_83; Uniclass2015Description: Stools; Uniclass2015Reference: Pr_40_50_12_85; Version: 1; VersionDate: 18/12/2018
Identity Data(Type) - Collection: Cork; Cost: 0; Description: The three robust members of the Cork Family stand firmly, making them suited for use as side tables or stools. They benefit from the advantageous natural properties of cork: comparatively lightweight and extremely durable, they also have a velvety surface that is pleasant to touch.; Designer: Jasper Morrison; Manufacturer: Vitra; Model: Cork - Model C; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-au/_storage/asset/204168/storage/master/download/FS_Cork_Family-EN_Preview-Single-Page.pdf; Type Name: Cork - Model C; URL: https://www.vitra.com/en-au/product/cork-family
Materials and Finishes(Type) - ChairMainMaterial: Untreated cork
Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_CorkC; Features: n/a; Finish: Untreated surface; Grade: n/a; Material: Solid turned cork; ModelNumber: n/a; ModelReference: 21002401; Name: DmstcChrs_CorkC; ReplacementCost: n/a; Shape: Sculptured; Size: 310x310x330 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
